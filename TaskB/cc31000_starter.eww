<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cc31000_starter.ewp</path>
  </project>
  <batchBuild/>
</workspace>
